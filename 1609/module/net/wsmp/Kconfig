## 1609/module/net/wsmp/Kconfig
```kconfig
config WSMP_NET
	default m
	tristate "Include WSMP support"
	help
	  "Allow usage of WSMP tx/rx functions & handling"
```
